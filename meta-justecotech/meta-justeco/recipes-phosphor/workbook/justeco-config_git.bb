SUMMARY = "Justeco HPC board wiring"
DESCRIPTION = "Board wiring information for the Justeco HPC system."
PR = "r1"
PV = "1.0+git${SRCPV}"

inherit config-in-skeleton
